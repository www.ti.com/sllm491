| From trsf3243e_rhb.ibs, TRSF3243E_RHB, Texas Instruments, Inc.
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[Model]   DOUT_5p0
Model_type   3-state
Polarity   Inverting
Vmeas = 2.5
Vref = 0
Cref = 150pF
Rref = 3000
|   typ   min   max
C_comp   6.70pF   5.86pF   7.51pF
[Voltage Range]   11.6   10.8   12.6
[Temperature Range]   27   110   -40
[Pullup Reference]   5.8   5.4   6.3
[Pulldown Reference]   -5.8   -5.4   -6.3
[Power Clamp Reference]   5.8   5.4   6.3
[GND Clamp Reference]   -5.8   -5.4   -6.3
| Worked out from all points:
|   slope of the pulldown table from 0 to 1.74 V, typ, clamps not added: 52 ohm
|   slope of the pullup table from 0 to 1.74 V, typ, clamps not added: 74.4 ohm
|   falling waveform, V_fixture 5.8V, R_fixture 3000Ohm: 20-80 % time 97.1ns typ, 133ns min, 68.5ns max; typ from 5.8 V to -5.65 V
|   rising waveform, V_fixture -5.8V, R_fixture 3000Ohm: 20-80 % time 105ns typ, 145ns min, 74.3ns max; typ from -5.8 V to 5.67 V
|   rising waveform, V_fixture 5.8V, R_fixture 3000Ohm: 20-80 % time 107ns typ, 156ns min, 73.8ns max; typ from -5.65 V to 5.8 V
|   falling waveform, V_fixture -5.8V, R_fixture 3000Ohm: 20-80 % time 97.2ns typ, 140ns min, 67.4ns max; typ from 5.67 V to -5.8 V
[Pulldown]
|   Voltage   I(typ)   I(min)   I(max)
-1V       -20.69mA   -13.21mA   -29.48mA
121.7mV   2.419mA    1.551mA    3.562mA
975.3mV   19.36mA    11.94mA    28.26mA
1.525V    29.58mA    17.81mA    43.51mA
1.856V    35.45mA    20.31mA    43.81mA
2.156V    35.58mA    20.85mA    44.08mA
3.033V    35.96mA    20.07mA    44.64mA
4.428V    36.57mA    20.23mA    44.94mA
4.464V    36.58mA    20.4mA     44.96mA
4.586V    36.64mA    22.27mA    45.02mA
4.713V    36.69mA    25.62mA    45.08mA
6.8V      37.6mA     26.51mA    45.97mA
[GND Clamp]
|   Voltage   I(typ)   I(min)   I(max)
-1V       -3.828uA   -3.033uA   -4.999uA
-1V       -3.729uA   -2.935uA   -4.897uA
-1V       -3.633uA   -2.843uA   -4.8uA
-1V       -3.593uA   -2.8uA     -4.764uA
-999.5mV  -3.593uA   -2.77uA    -4.754uA
13.97mV   -2.834uA   -2.146uA   -3.855uA
260.5mV   -2.633uA   -1.949uA   -3.625uA
2.117V    -478.6nA   -12.17nA   -1.131uA
2.356V    -199.1nA   0A         -810nA
2.607V    0A         0A         -474.9nA
2.963V    0A         0A         -296.8pA
12.4V     0A         0A         0A
[Pullup]
|   Voltage   I(typ)   I(min)   I(max)
-1V       1.515mA    1.439mA    1.621mA
-879.7mV  1.49mA     1.621mA    1.68mA
-867.2mV  1.487mA    10.06mA    1.686mA
-754.3mV  1.464mA    10.08mA    1.741mA
-751.8mV  1.463mA    10.05mA    2.775mA
-748.2mV  1.462mA    10.01mA    15.68mA
-731.7mV  1.459mA    9.793mA    17.19mA
-53.21mV  1.318mA    1.073mA    1.672mA
1.17V     -16.99mA   -11.84mA   -22.7mA
2.364V    -25.94mA   -19mA      -34.69mA
11.52V    -28.85mA   -21.39mA   -38.47mA
12.4V     -28.98mA   -40.82mA   -38.63mA
[POWER Clamp]
|   Voltage   I(typ)   I(min)   I(max)
-1V       6.157uA    5.999uA    6.994uA
-1V       5.92uA     5.764uA    6.758uA
-999.7mV  5.92uA     5.733uA    6.752uA
-869.8mV  5.851uA    5.624uA    6.68uA
5.338V    2.726uA    2.381uA    3.419uA
5.578V    2.606uA    2.053uA    3.293uA
6.628V    2.069uA    1.428uA    2.742uA
7.298V    1.402uA    787.7nA    2.337uA
8.048V    593nA      34.14nA    1.497uA
8.558V    31.61nA    0A         871.9nA
9.193V    0A         0A         36.79nA
12.4V     0A         0A         0A
[Ramp]
R_load = 3000
|   typ   min   max
dV/dt_r   6.88152/1.04841e-07   6.37005/1.44778e-07   7.49789/7.41834e-08
dV/dt_f   6.86903/9.69494e-08   6.33369/1.32531e-07   7.49887/6.84103e-08
[Falling Waveform]
V_fixture = 5.8V
V_fixture_min = 5.4V
V_fixture_max = 6.3V
R_fixture = 3000Ohm
C_fixture = 0F
|   Time   V(typ)   V(min)   V(max)
0s        5.8V       5.4V       6.3V
77.23ns   5.948V     5.562V     6.198V
120.7ns   5.653V     5.552V     1.6V
184.9ns   1.288V     5.156V     -5.111V
219.5ns   -1.175V    3.82V      -6.138V
271.9ns   -4.596V    1.278V     -6.166V
292.3ns   -5.322V    279.8mV    -6.175V
389.4ns   -5.627V    -4.127V    -6.198V
462.9ns   -5.647V    -5.058V    -6.198V
4us       -5.649V    -5.157V    -6.198V
[Rising Waveform]
V_fixture = -5.8V
V_fixture_min = -5.4V
V_fixture_max = -6.3V
R_fixture = 3000Ohm
C_fixture = 0F
|   Time   V(typ)   V(min)   V(max)
0s        -5.8V      -5.399V    -6.3V
79.45ns   -5.889V    -5.417V    -6.066V
126.7ns   -5.417V    -5.488V    -1.687V
199.4ns   -1.055V    -4.845V    5.383V
228.2ns   848.6mV    -3.895V    6.133V
290.6ns   4.782V     -1.255V    6.176V
306.8ns   5.364V     -536.3mV   6.18V
419.4ns   5.645V     4.352V     6.189V
477.3ns   5.652V     5.108V     6.194V
4us       5.67V      5.217V     6.197V
[Rising Waveform]
V_fixture = 5.8V
V_fixture_min = 5.4V
V_fixture_max = 6.3V
R_fixture = 3000Ohm
C_fixture = 0F
|   Time   V(typ)   V(min)   V(max)
0s        -5.649V    -5.157V    -6.198V
39.12ns   -5.647V    -5.155V    -6.235V
77.81ns   -5.318V    -5.163V    -5.19V
125.5ns   -4.142V    -4.61V     -729.8mV
187.9ns   -502.6mV   -3.4V      5.458V
214.8ns   1.28V      -2.609V    6.275V
288.2ns   5.571V     317.6mV    6.285V
390.5ns   5.78V      4.725V     6.292V
440.2ns   5.784V     5.365V     6.295V
4us       5.8V       5.4V       6.3V
[Falling Waveform]
|Gnd
V_fixture = -5.8V
V_fixture_min = -5.4V
V_fixture_max = -6.3V
R_fixture = 3000Ohm
C_fixture = 0F
|   Time   V(typ)   V(min)   V(max)
0s        5.67V      5.217V     6.197V
29.12ns   5.667V     5.216V     6.356V
76.14ns   5.144V     5.217V     5.143V
118.6ns   4.171V     4.385V     654.5mV
174.9ns   437.4mV    3.332V     -5.287V
205.6ns   -1.776V    2.279V     -6.27V
270.5ns   -5.541V    -736.2mV   -6.287V
353.9ns   -5.778V    -4.57V     -6.299V
412.3ns   -5.791V    -5.347V    -6.299V
4us       -5.8V      -5.399V    -6.3V
