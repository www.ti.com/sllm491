| From trsf3243e_rhb.ibs, TRSF3243E_RHB, Texas Instruments, Inc.
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[Model]   DOUT_3p3
Model_type   3-state
Polarity   Inverting
Vmeas = 2.5
Vref = 0
Cref = 150pF
Rref = 3000
|   typ   min   max
C_comp   6.67pF   5.86pF   7.62pF
[Voltage Range]   11.6   10.8   12.6
[Temperature Range]   27   110   -40
[Pullup Reference]   5.8   5.4   6.3
[Pulldown Reference]   -5.8   -5.4   -6.3
[Power Clamp Reference]   5.8   5.4   6.3
[GND Clamp Reference]   -5.8   -5.4   -6.3
| Worked out from all points:
|   slope of the pulldown table from 0 to 1.74 V, typ, clamps not added: 52 ohm
|   slope of the pullup table from 0 to 1.74 V, typ, clamps not added: 74.3 ohm
|   falling waveform, V_fixture 5.8V, R_fixture 3000Ohm: 20-80 % time 104ns typ, 141ns min, 74.6ns max; typ from 5.8 V to -5.65 V
|   rising waveform, V_fixture -5.8V, R_fixture 3000Ohm: 20-80 % time 114ns typ, 154ns min, 83.6ns max; typ from -5.8 V to 5.67 V
|   rising waveform, V_fixture 5.8V, R_fixture 3000Ohm: 20-80 % time 117ns typ, 166ns min, 83.5ns max; typ from -5.65 V to 5.8 V
|   falling waveform, V_fixture -5.8V, R_fixture 3000Ohm: 20-80 % time 105ns typ, 152ns min, 73.8ns max; typ from 5.67 V to -5.8 V
[Pulldown]
|   Voltage   I(typ)   I(min)   I(max)
-1V       -20.69mA   -13.21mA   -29.48mA
121.7mV   2.419mA    1.551mA    3.562mA
975.3mV   19.36mA    11.94mA    28.26mA
1.525V    29.58mA    17.81mA    43.51mA
1.856V    35.45mA    20.31mA    43.81mA
2.156V    35.58mA    20.85mA    44.08mA
3.033V    35.96mA    20.07mA    44.64mA
4.428V    36.57mA    20.23mA    44.94mA
4.464V    36.58mA    20.4mA     44.96mA
4.586V    36.64mA    22.27mA    45.02mA
4.713V    36.69mA    25.62mA    45.08mA
6.8V      37.6mA     26.51mA    45.97mA
[GND Clamp]
|   Voltage   I(typ)   I(min)   I(max)
-1V       -3.828uA   -3.033uA   -4.999uA
-1V       -3.729uA   -2.935uA   -4.897uA
-1V       -3.633uA   -2.843uA   -4.8uA
-1V       -3.603uA   -2.812uA   -4.773uA
-1V       -3.593uA   -2.8uA     -4.764uA
-999.5mV  -3.593uA   -2.77uA    -4.754uA
33.63mV   -2.819uA   -2.134uA   -3.836uA
262.9mV   -2.631uA   -1.948uA   -3.623uA
2.116V    -479.6nA   -13.05nA   -1.133uA
2.526V    -1.988nA   0A         -583.2nA
2.962V    0A         0A         -1.287nA
12.4V     0A         0A         0A
[Pullup]
|   Voltage   I(typ)   I(min)   I(max)
-1V       1.513mA    1.437mA    1.617mA
-839.2mV  1.349mA    11.13mA    1.676mA
-754.2mV  1.262mA    10.07mA    1.707mA
-751.2mV  1.259mA    10.03mA    2.945mA
-749.7mV  1.258mA    10.01mA    12.47mA
-747.7mV  1.256mA    9.983mA    15.67mA
-730mV    1.238mA    9.756mA    17.16mA
-4.915mV  499.4uA    489.8uA    543.6uA
1.178V    -17.09mA   -11.91mA   -22.82mA
2.364V    -25.91mA   -18.92mA   -34.63mA
11.52V    -28.81mA   -21.36mA   -38.39mA
12.4V     -28.94mA   -40.79mA   -38.55mA
[POWER Clamp]
|   Voltage   I(typ)   I(min)   I(max)
-1V       6.157uA    5.999uA    6.994uA
-1V       5.963uA    5.809uA    6.797uA
-1V       5.92uA     5.764uA    6.758uA
-999.7mV  5.92uA     5.733uA    6.752uA
-867.8mV  5.85uA     5.623uA    6.679uA
5.185V    2.801uA    2.467uA    3.499uA
6.081V    2.356uA    1.832uA    3.03uA
7.194V    1.345uA    890.6nA    2.422uA
8.028V    587.9nA    55nA       1.524uA
8.675V    0A         0A         718.5nA
9.317V    0A         0A         0A
12.4V     0A         0A         0A
[Ramp]
R_load = 3000
|   typ   min   max
dV/dt_r   6.88153/1.14399e-07   6.37007/1.54144e-07   7.49789/8.35583e-08
dV/dt_f   6.8684/1.03991e-07   6.3323/1.40933e-07   7.49846/7.45385e-08
[Falling Waveform]
V_fixture = 5.8V
V_fixture_min = 5.4V
V_fixture_max = 6.3V
R_fixture = 3000Ohm
C_fixture = 0F
|   Time   V(typ)   V(min)   V(max)
0s        5.8V       5.4V       6.3V
83.24ns   5.942V     5.556V     6.163V
139ns     5.204V     5.543V     669.8mV
200.4ns   1.139V     5.122V     -5.161V
234.6ns   -1.128V    3.879V     -6.134V
291ns     -4.601V    1.34V      -6.166V
312.8ns   -5.336V    353.2mV    -6.177V
417.2ns   -5.629V    -4.162V    -6.197V
487.7ns   -5.647V    -5.048V    -6.197V
4us       -5.648V    -5.154V    -6.198V
[Rising Waveform]
V_fixture = -5.8V
V_fixture_min = -5.4V
V_fixture_max = -6.3V
R_fixture = 3000Ohm
C_fixture = 0F
|   Time   V(typ)   V(min)   V(max)
0s        -5.8V      -5.399V    -6.3V
83.83ns   -5.887V    -5.398V    -6.015V
119.4ns   -5.78V     -5.484V    -3.24V
141ns     -5.099V    -5.487V    -1.261V
218.4ns   -683.8mV   -4.606V    5.425V
247.2ns   1.064V     -3.646V    6.129V
330.1ns   5.396V     -275.3mV   6.179V
443.7ns   5.644V     4.354V     6.19V
504.8ns   5.653V     5.109V     6.196V
4us       5.67V      5.217V     6.197V
[Rising Waveform]
V_fixture = 5.8V
V_fixture_min = 5.4V
V_fixture_max = 6.3V
R_fixture = 3000Ohm
C_fixture = 0F
|   Time   V(typ)   V(min)   V(max)
0s        -5.648V    -5.154V    -6.198V
40.44ns   -5.646V    -5.153V    -6.234V
82.16ns   -5.298V    -5.152V    -5.101V
139ns     -3.824V    -4.49V     -343.4mV
205.5ns   -154.9mV   -3.181V    5.494V
232.4ns   1.467V     -2.398V    6.273V
309.3ns   5.589V     508.4mV    6.285V
415.1ns   5.782V     4.777V     6.292V
465.7ns   5.786V     5.367V     6.296V
4us       5.8V       5.4V       6.3V
[Falling Waveform]
|Gnd
V_fixture = -5.8V
V_fixture_min = -5.4V
V_fixture_max = -6.3V
R_fixture = 3000Ohm
C_fixture = 0F
|   Time   V(typ)   V(min)   V(max)
0s        5.67V      5.217V     6.197V
31.19ns   5.668V     5.216V     6.346V
82.49ns   5.084V     5.229V     5.021V
129.6ns   3.989V     4.307V     435.3mV
189.5ns   262.1mV    3.207V     -5.344V
220.9ns   -1.837V    2.214V     -6.272V
288.8ns   -5.546V    -713.9mV   -6.288V
378ns     -5.78V     -4.575V    -6.299V
438.3ns   -5.793V    -5.349V    -6.299V
4us       -5.8V      -5.399V    -6.3V
